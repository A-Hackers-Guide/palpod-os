# Repository A-Hackers-Guide/palpod-os (continued)

## KiCad design hardware/electrical/kicad/palpod-compute-backplane/palpod-compute-backplane-real.kicad_pcb

File hardware/electrical/kicad/palpod-compute-backplane/README.md (part):

# Hearth Compute Backplane - KiCad Project

The compute backplane is the highest-complexity PCB in the Hearth system:
a 14-layer, 450x300 mm carrier that hosts **10x NVIDIA Jetson Orin NX**
SO-DIMM modules (JAE MM70-260B1-R1 260-pin sockets) and **10x AMD Ryzen AI 9
HX 370** mini-SBC daughtercards (Samtec ExaMAX 56 Gbps mezzanine), stitched
together by a **Broadcom BCM56780 Trident 4** 12.8 Tbps switch fabric, with
PCIe Gen 5 signal integrity closed by an **Astera Labs Aries PT4** retimer,
40+ power rails managed by a **TI UCD90320** sequencer, chassis health tied
to a **Nuvoton NCT6116** BMC, and root-of-trust in an **Infineon SLB9670**
TPM 2.0.

Real high-speed routing (100 GbE, PCIe Gen 5) is 6-12 weeks of an SI
engineer's work; this project is the KiCad **setup stub** that gets the EE
past scaffolding: file layout, library tables, symbol/footprint placeholders,
14-layer stackup, net classes, board outline, and validated tooling.

See `../block-diagrams/compute-backplane.md` for the block-level
architecture and topology.

## How to open

Requires **KiCad 8.0.0 or later** (KiCad 9 and 10 also open the files
cleanly; developed and validated against KiCad 10.0.5 on macOS).

```
open -a KiCad /private/tmp/claude-501/-Users-lexer-kindle/80e67baf-6192-4db2-b491-aa5b4ee00c5b/scratchpad/palpod-os/hardware/electrical/kicad/palpod-compute-backplane/palpod-compute-backplane.kicad_pro
```

Or double-click `palpod-compute-backplane.kicad_pro` in Finder. From the
KiCad project manager, open **Schematic Editor** and **PCB Editor**.

The project defines a project-local symbol and footprint library in
`libraries/`; `sym-lib-table` and `fp-lib-table` at the project root
register them under the alias `palpod-compute-backplane`. Standard KiCad
symbols (`Device:R`, `Device:C`, `power:+12V/+5V/+3V3/+1V8/+0V9/GND`) are
embedded in the schematic's `lib_symbols` block so the sheet loads even if a
fresh KiCad install has not yet had its stock libraries configured; on first
save KiCad will link them back to the real stdlib entries.

## What's populated

### Project (`.kicad_pro`)

- 14-layer stackup declared:
  `F.Cu / GND1 / SIG1 / GND2 / SIG2 / PWR12V / PWR3V3 / PWR1V8 / PWR_ANALOG / SIG3 / GND3 / SIG4 / GND4 / B.Cu`
- Copper: 1 oz outer / 0.5 oz inner, finish **ENIG**
- Dielectric: **Megtron 6** (Er 3.4, tan-delta 0.004) - required for PCIe
  Gen 5 loss budget
- Net classes:
  - `Default` - 0.2 mm track, 0.6 mm via
  - `HS_DIFF_100R` - 100 ohm diff pair, 0.1 mm width / 0.1 mm gap, 0.35 mm via
  - `PCIe_G5` - PCIe Gen 5 diff pair, 0.1 mm / 0.11 mm gap
  - `ETH_100G` - 100 GbE diff pair, 0.09 mm / 0.09 mm gap
  - `PWR_12V` - 1.0 mm track, 1.2 mm via (light budget - real 12V distribution needs bus bars or copper pours)
  - `PWR_LOW_VOLTAGE` - 0.4 mm track, 0.8 mm via
- Netclass auto-assignment patterns for `+12V/+5V/+3V3/+1V8/+0V9`, `ETH*`,
  `*PCIE*`, `PEX0_*`, `USB*`, `MGBE*`
- DRC minimums tuned for 4/4 mil fab (0.09 mm track, 0.1 mm clearance)

### Schematic (`.kicad_sch`)

- A0 sheet, populated title block (rev A0, 2026-08-03)
- Embedded `lib_symbols` for every reference used
- **10 x JAE MM70-260B1-R1 SODIMM** connectors (J1..J10) in a horizontal row across the top
- **10 x Samtec ExaMAX-200** mezzanine connectors (J11..J20) in a horizontal row across the bottom
- **BCM56780** (U1) - center of the sheet
- **Aries PT4** PCIe Gen5 retimer (U2) - left of switch
- **UCD90320** 32-rail power sequencer (U3) - right of switch
- **NCT6116** BMC (U4)
- **SLB9670** TPM 2.0 (U5)
- **TPS543x** buck-regulator block (U6) with input bulk cap (C1), input decouple (C2), output bulk (C3), output decouple (C4), feedback divider (R1, R2)
- **2 x ATX24** PSU input connectors (J21, J22) for the redundant 1500 W Titanium PSUs
- Power flags: `+12V`, `+5V`, `+3V3`, `+1V8`, `+0V9`, `GND`
- Illustrative wires + labels: `+12V` from ATX24 to buck input, `+5V` on
  buck output, `PMBUS_CLK/DAT` from UCD90320 to BMC, `ETH0_TX_P` from
  switch to Ryzen0 - just enough to demonstrate the wiring pattern

### Symbol library (`libraries/palpod-compute-backplane.kicad_sym`)

Hand-drawn placeholder symbols. **Pin groupings are functional
abstractions; the EE MUST verify each pin against the manufacturer
datasheet before wiring.**

| Symbol | Pins | Package | Notes |
|---|---|---|---|
| `MM70_260_SODIMM` | 260 | JAE MM70-260B1-R1 | PCIe/USB/UART/I2C/HDMI/DP/CSI groups |
| `SAMTEC_EXAMAX_200` | 200 | Samtec ExaMAX 56G | PCIe Gen5 x8 + 100GbE x4 + USB3 + JTAG + power |
| `BCM56780` | ~180 | HFCBGA-1300 | 32 SerDes quads + PCIe host + JTAG + PMBus + power (grouped; real device is 1300 balls) |
| `ARIES_PT4` | ~80 | BGA-544 | 8 upstream + 8 downstream PCIe Gen5 lanes + REFCLK + I2C mgmt |
| `UCD90320` | ~75 | BGA-173 | 32 EN outs + 32 PGOOD ins + PMBus + JTAG |
| `NCT6116` | ~50 | LQFP-128 | 6 fan tach/PWM + pump tach/PWM + 5 temp ADCs + SPI + I2C + LED outs |
| `TPS543x` | 16 | QFN-16 5x5 | Buck regulator with feedback + SS_TR + PGOOD |
| `SLB9670` | 12 | TSSOP-28 | TPM 2.0 SPI |
| `ATX24` | 24 | Molex 39-01-2240 | ATX main power input |

### Footprint library (`libraries/palpod-compute-backplane.pretty/`)

Placeholder outlines with correct package footprint (body size, pad
positions on a regular grid, pin 1 markers, silkscreen/courtyard/fab
layers).  **These are geometrically correct enough to place on the board
but the exact pad shapes and ball map MUST be verified against the
manufacturer drawing before ordering fab.**

- `MM70_260_SODIMM.kicad_mod` - 2 rows of 130 pads, 0.5 mm pitch, 68x5 mm body
- `SAMTEC_EXAMAX_200.kicad_mod` - 4 rows of 50 pads, 0.8 mm pitch
- `BCM56780_HFCBGA1300.kicad_mod` - 36x36 BGA grid, 1 mm pitch, 40x40 mm body
- `ARIES_PT4_BGA544.kicad_mod` - 24x24 BGA grid, 1 mm pitch, 24x24 mm body
- `UCD90320_BGA173.kicad_mod` - 15x12 BGA grid, 1 mm pitch, 15x12 mm body
- `NCT6116_LQFP128.kicad_mod` - 32 pads x 4 sides, 0.5 mm pitch, 20x20 mm body
- `TPS543x_QFN.kicad_mod` - QFN-16 + thermal pad, 0.65 mm pitch, 5x5 mm body
- `SLB9670_TSSOP28.kicad_mod` - TSSOP-28, 0.65 mm pitch, 4.4x9.7 mm body
- `ATX24_HEADER.kicad_mod` - 2 rows of 12 through-hole pins, 4.2 mm pitch

### PCB (`.kicad_pcb`)

- 14 copper layers matching the project stackup, ENIG finish, Megtron 6 dielectric
- **450 mm x 300 mm rectangular** board outline drawn on `Edge.Cuts`
- 6 M3 mounting holes (4 corners + 2 mid-edges)
- Nets pre-defined: `GND`, `+12V`, `+5V`, `+3V3`, `+1V8`, `+0V9`,
  `PMBUS_*`, `SYS_*`, `PCIE_REFCLK_P/N`, plus **128 ETH lane nets**
  (`ETH0_TX_P` .. `ETH31_RX_N`) and **320 PCIe lane nets**
  (`RYZEN0_PCIE0_TX_P` .. `RYZEN9_PCIE7_RX_N`)
- Silkscreen title block + rev A0 marker + fab note pointing at the block diagram
- No footprints placed yet - the EE places them during layout

## What's stubbed / next steps for the EE

- [ ] **Verify placeholder symbol pin maps against manufacturer datasheets.**
  Every symbol here is a black-box abstraction; the pin numbers/names
  chosen are best-guess groupings. Broadcom, Astera, JAE, Samtec, TI,
  Nuvoton and Infineon each ship a full pin-out. Update
  `libraries/palpod-compute-backplane.kicad_sym` before wiring.
- [ ] **Verify placeholder footprints against manufacturer land-pattern
  drawings.** Body sizes are correct; exact pad shapes/sizes/ball maps
  need to match the mechanical drawing.  Especially critical for the
  BCM56780 HFCBGA-1300 (thermal pad, dummy balls, corner keepouts).
- [ ] Wire the schematic:
  - **PCIe Gen 5 x4 from each of 10 Ryzen ExaMAX slots to the Aries PT4
    retimer** (downstream side), then Aries upstream x16 fanned to the
    BCM56780 host PCIe. That's 80 PCIe TX/RX lanes = 160 diff pairs.
  - **100 GbE from each of the 20 slots to the BCM56780** (10 Jetson +
    10 Ryzen), plus SFP28/QSFP uplink ports. Route via the switch's 32
    SerDes quads on layers SIG2/SIG3.
  - **PCIe REFCLK distribution** - 100 MHz HCSL from a central buffer
    (IDT 9DBL0651 or similar - add to schematic) to each slot and to
    the Aries and BCM56780.
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
Schematic: palpod-compute-backplane-real.kicad_sch, Hearth Compute Backplane

Parts:
C1: 470uF/25V; CP_Elec_10x10.5
C2: 10uF/25V; C_0805_2012Metric
C3: 220uF/16V; CP_Elec_8x10.5
C4: 10uF/6.3V; C_0603_1608Metric
J1: MM70_260_SODIMM (Jetson Orin NX #0); MM70_260_SODIMM
J2: MM70_260_SODIMM (Jetson Orin NX #1); MM70_260_SODIMM
J3: MM70_260_SODIMM (Jetson Orin NX #2); MM70_260_SODIMM
J4: MM70_260_SODIMM (Jetson Orin NX #3); MM70_260_SODIMM
J5: MM70_260_SODIMM (Jetson Orin NX #4); MM70_260_SODIMM
J6: MM70_260_SODIMM (Jetson Orin NX #5); MM70_260_SODIMM
J7: MM70_260_SODIMM (Jetson Orin NX #6); MM70_260_SODIMM
J8: MM70_260_SODIMM (Jetson Orin NX #7); MM70_260_SODIMM
J9: MM70_260_SODIMM (Jetson Orin NX #8); MM70_260_SODIMM
J10: MM70_260_SODIMM (Jetson Orin NX #9); MM70_260_SODIMM
J11: SAMTEC_EXAMAX_200 (Ryzen AI 9 HX 370 #0); SAMTEC_EXAMAX_200
J12: SAMTEC_EXAMAX_200 (Ryzen AI 9 HX 370 #1); SAMTEC_EXAMAX_200
J13: SAMTEC_EXAMAX_200 (Ryzen AI 9 HX 370 #2); SAMTEC_EXAMAX_200
J14: SAMTEC_EXAMAX_200 (Ryzen AI 9 HX 370 #3); SAMTEC_EXAMAX_200
J15: SAMTEC_EXAMAX_200 (Ryzen AI 9 HX 370 #4); SAMTEC_EXAMAX_200
J16: SAMTEC_EXAMAX_200 (Ryzen AI 9 HX 370 #5); SAMTEC_EXAMAX_200
J17: SAMTEC_EXAMAX_200 (Ryzen AI 9 HX 370 #6); SAMTEC_EXAMAX_200
J18: SAMTEC_EXAMAX_200 (Ryzen AI 9 HX 370 #7); SAMTEC_EXAMAX_200
J19: SAMTEC_EXAMAX_200 (Ryzen AI 9 HX 370 #8); SAMTEC_EXAMAX_200
J20: SAMTEC_EXAMAX_200 (Ryzen AI 9 HX 370 #9); SAMTEC_EXAMAX_200
J21: ATX24 (+12V PSU input); ATX24_HEADER
J22: ATX24 (+12V PSU input B); ATX24_HEADER
R1: 10k; R_0402_1005Metric
R2: 3.3k; R_0402_1005Metric
U1: BCM56780 (Trident 4 12.8Tbps); BCM56780_HFCBGA1300
U2: ARIES_PT4 (PCIe Gen5 retimer); ARIES_PT4_BGA544
U3: UCD90320 (32-rail sequencer); UCD90320_BGA173
U4: NCT6116 (BMC / super-I/O); NCT6116_LQFP128
U5: SLB9670 (TPM 2.0); SLB9670_TSSOP28
U6: TPS543x (12V -> 5V, 15A); TPS543x_QFN

Connections (part):
+0V9: U2.77 (VDD_CORE_0V9), U2.78 (VDD_CORE_0V9)
+1V8: U2.79 (VDD_1V8), U2.80 (VDD_1V8), U3.78 (VCC_1V8), U4.40 (VCC_1V8), U5.10 (VCC_1V8)
+3V3: J1.33 (VDD_IN), J1.34 (VDD_IN), J1.35 (VDD_IN), J1.36 (VDD_IN), J1.131 (VDD_IN), J1.132 (VDD_IN), J1.133 (VDD_IN), J1.134 (VDD_IN), J2.33 (VDD_IN), J2.34 (VDD_IN), J2.35 (VDD_IN), J2.36 (VDD_IN), J2.131 (VDD_IN), J2.132 (VDD_IN), J2.133 (VDD_IN), J2.134 (VDD_IN), J3.33 (VDD_IN), J3.34 (VDD_IN), J3.35 (VDD_IN), J3.36 (VDD_IN), J3.131 (VDD_IN), J3.132 (VDD_IN), J3.133 (VDD_IN), J3.134 (VDD_IN), J4.33 (VDD_IN), J4.34 (VDD_IN), J4.35 (VDD_IN), J4.36 (VDD_IN), J4.131 (VDD_IN), J4.132 (VDD_IN), J4.133 (VDD_IN), J4.134 (VDD_IN), J5.33 (VDD_IN), J5.34 (VDD_IN), J5.35 (VDD_IN), J5.36 (VDD_IN), J5.131 (VDD_IN), J5.132 (VDD_IN), J5.133 (VDD_IN), J5.134 (VDD_IN), J6.33 (VDD_IN), J6.34 (VDD_IN), J6.35 (VDD_IN), J6.36 (VDD_IN), J6.131 (VDD_IN), J6.132 (VDD_IN), J6.133 (VDD_IN), J6.134 (VDD_IN), J7.33 (VDD_IN), J7.34 (VDD_IN), J7.35 (VDD_IN), J7.36 (VDD_IN), J7.131 (VDD_IN), J7.132 (VDD_IN), J7.133 (VDD_IN), J7.134 (VDD_IN), J8.33 (VDD_IN), J8.34 (VDD_IN), J8.35 (VDD_IN), J8.36 (VDD_IN), J8.131 (VDD_IN), J8.132 (VDD_IN), J8.133 (VDD_IN), J8.134 (VDD_IN), J9.33 (VDD_IN), J9.34 (VDD_IN), J9.35 (VDD_IN), J9.36 (VDD_IN), J9.131 (VDD_IN), J9.132 (VDD_IN), J9.133 (VDD_IN), J9.134 (VDD_IN), J10.33 (VDD_IN), J10.34 (VDD_IN), J10.35 (VDD_IN), J10.36 (VDD_IN), J10.131 (VDD_IN), J10.132 (VDD_IN), J10.133 (VDD_IN), J10.134 (VDD_IN)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
+3V3_STBY: U4.41 (VCC_STBY_3V3)
+5V: C3.1, C4.1, J21.4 (+5V), J21.6 (+5V), J21.21 (+5V), J21.22 (+5V), J21.23 (+5V), J22.4 (+5V), J22.6 (+5V), J22.21 (+5V), J22.22 (+5V), J22.23 (+5V), R1.1, U6.7 (VOUT), U6.8 (VOUT)
+5VSB: J21.9 (+5VSB), J22.9 (+5VSB)
+12V: C1.1, C2.1, J11.101 (VDD_12V), J11.102 (VDD_12V), J11.103 (VDD_12V), J11.104 (VDD_12V), J11.105 (VDD_12V), J11.106 (VDD_12V), J11.107 (VDD_12V), J11.108 (VDD_12V), J11.109 (VDD_12V), J11.110 (VDD_12V), J11.111 (VDD_12V), J11.112 (VDD_12V), J11.113 (VDD_12V), J11.114 (VDD_12V), J11.115 (VDD_12V), J11.116 (VDD_12V), J11.117 (VDD_12V), J11.118 (VDD_12V), J11.119 (VDD_12V), J11.120 (VDD_12V), J11.121 (VDD_12V), J11.122 (VDD_12V), J11.123 (VDD_12V), J11.124 (VDD_12V), J11.125 (VDD_12V), J11.126 (VDD_12V), J11.127 (VDD_12V), J11.128 (VDD_12V), J11.129 (VDD_12V), J11.130 (VDD_12V), J11.131 (VDD_12V), J11.132 (VDD_12V), J11.133 (VDD_12V), J11.134 (VDD_12V), J11.135 (VDD_12V), J11.136 (VDD_12V), J11.137 (VDD_12V), J11.138 (VDD_12V), J11.139 (VDD_12V), J11.140 (VDD_12V), J12.101 (VDD_12V), J12.102 (VDD_12V), J12.103 (VDD_12V), J12.104 (VDD_12V), J12.105 (VDD_12V), J12.106 (VDD_12V), J12.107 (VDD_12V), J12.108 (VDD_12V), J12.109 (VDD_12V), J12.110 (VDD_12V), J12.111 (VDD_12V), J12.112 (VDD_12V), J12.113 (VDD_12V), J12.114 (VDD_12V), J12.115 (VDD_12V), J12.116 (VDD_12V), J12.117 (VDD_12V), J12.118 (VDD_12V), J12.119 (VDD_12V), J12.120 (VDD_12V), J12.121 (VDD_12V), J12.122 (VDD_12V), J12.123 (VDD_12V), J12.124 (VDD_12V), J12.125 (VDD_12V), J12.126 (VDD_12V), J12.127 (VDD_12V), J12.128 (VDD_12V), J12.129 (VDD_12V), J12.130 (VDD_12V), J12.131 (VDD_12V), J12.132 (VDD_12V), J12.133 (VDD_12V), J12.134 (VDD_12V), J12.135 (VDD_12V), J12.136 (VDD_12V), J12.137 (VDD_12V), J12.138 (VDD_12V)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
ARIES_DN_L0_RX_N: U2.36 (L0_DN_RX_N)
ARIES_DN_L0_RX_P: U2.35 (L0_DN_RX_P)
ARIES_DN_L0_TX_N: U2.34 (L0_DN_TX_N)
ARIES_DN_L0_TX_P: U2.33 (L0_DN_TX_P)
ARIES_DN_L1_RX_N: U2.40 (L1_DN_RX_N)
ARIES_DN_L1_RX_P: U2.39 (L1_DN_RX_P)
ARIES_DN_L1_TX_N: U2.38 (L1_DN_TX_N)
ARIES_DN_L1_TX_P: U2.37 (L1_DN_TX_P)
ARIES_DN_L2_RX_N: U2.44 (L2_DN_RX_N)
ARIES_DN_L2_RX_P: U2.43 (L2_DN_RX_P)
ARIES_DN_L2_TX_N: U2.42 (L2_DN_TX_N)
ARIES_DN_L2_TX_P: U2.41 (L2_DN_TX_P)
ARIES_DN_L3_RX_N: U2.48 (L3_DN_RX_N)
ARIES_DN_L3_RX_P: U2.47 (L3_DN_RX_P)
ARIES_DN_L3_TX_N: U2.46 (L3_DN_TX_N)
ARIES_DN_L3_TX_P: U2.45 (L3_DN_TX_P)
ARIES_DN_L4_RX_N: U2.52 (L4_DN_RX_N)
ARIES_DN_L4_RX_P: U2.51 (L4_DN_RX_P)
ARIES_DN_L4_TX_N: U2.50 (L4_DN_TX_N)
ARIES_DN_L4_TX_P: U2.49 (L4_DN_TX_P)
ARIES_DN_L5_RX_N: U2.56 (L5_DN_RX_N)
ARIES_DN_L5_RX_P: U2.55 (L5_DN_RX_P)
ARIES_DN_L5_TX_N: U2.54 (L5_DN_TX_N)
ARIES_DN_L5_TX_P: U2.53 (L5_DN_TX_P)
ARIES_DN_L6_RX_N: U2.60 (L6_DN_RX_N)
ARIES_DN_L6_RX_P: U2.59 (L6_DN_RX_P)
ARIES_DN_L6_TX_N: U2.58 (L6_DN_TX_N)
ARIES_DN_L6_TX_P: U2.57 (L6_DN_TX_P)
ARIES_DN_L7_RX_N: U2.64 (L7_DN_RX_N)
ARIES_DN_L7_RX_P: U2.63 (L7_DN_RX_P)
ARIES_DN_L7_TX_N: U2.62 (L7_DN_TX_N)
ARIES_DN_L7_TX_P: U2.61 (L7_DN_TX_P)
ARIES_PERST_DN_L: U2.70 (PERST_DN_L)
ARIES_PERST_UP_L: U1.139 (PCIE_HOST_PERST_L), U2.69 (PERST_UP_L)
ARIES_READY: U2.76 (READY)
ARIES_REFCLK_DN_N: U2.68 (REFCLK_DN_N)
ARIES_REFCLK_DN_P: U2.67 (REFCLK_DN_P)
ARIES_REFCLK_UP_N: U1.138 (PCIE_HOST_REFCLK_N), U2.66 (REFCLK_UP_N)
ARIES_REFCLK_UP_P: U1.137 (PCIE_HOST_REFCLK_P), U2.65 (REFCLK_UP_P)
ARIES_UP_L0_RX_N: U1.136 (PCIE_HOST_RX_N), U2.4 (L0_UP_RX_N)
ARIES_UP_L0_RX_P: U1.135 (PCIE_HOST_RX_P), U2.3 (L0_UP_RX_P)
ARIES_UP_L0_TX_N: U1.134 (PCIE_HOST_TX_N), U2.2 (L0_UP_TX_N)
ARIES_UP_L0_TX_P: U1.133 (PCIE_HOST_TX_P), U2.1 (L0_UP_TX_P)
ARIES_UP_L1_RX_N: U2.8 (L1_UP_RX_N)
ARIES_UP_L1_RX_P: U2.7 (L1_UP_RX_P)
ARIES_UP_L1_TX_N: U2.6 (L1_UP_TX_N)
ARIES_UP_L1_TX_P: U2.5 (L1_UP_TX_P)
ARIES_UP_L2_RX_N: U2.12 (L2_UP_RX_N)
ARIES_UP_L2_RX_P: U2.11 (L2_UP_RX_P)
ARIES_UP_L2_TX_N: U2.10 (L2_UP_TX_N)
ARIES_UP_L2_TX_P: U2.9 (L2_UP_TX_P)
ARIES_UP_L3_RX_N: U2.16 (L3_UP_RX_N)
ARIES_UP_L3_RX_P: U2.15 (L3_UP_RX_P)
ARIES_UP_L3_TX_N: U2.14 (L3_UP_TX_N)
ARIES_UP_L3_TX_P: U2.13 (L3_UP_TX_P)
ARIES_UP_L4_RX_N: U2.20 (L4_UP_RX_N)
ARIES_UP_L4_RX_P: U2.19 (L4_UP_RX_P)
ARIES_UP_L4_TX_N: U2.18 (L4_UP_TX_N)
ARIES_UP_L4_TX_P: U2.17 (L4_UP_TX_P)
ARIES_UP_L5_RX_N: U2.24 (L5_UP_RX_N)
ARIES_UP_L5_RX_P: U2.23 (L5_UP_RX_P)
ARIES_UP_L5_TX_N: U2.22 (L5_UP_TX_N)
ARIES_UP_L5_TX_P: U2.21 (L5_UP_TX_P)
ARIES_UP_L6_RX_N: U2.28 (L6_UP_RX_N)
ARIES_UP_L6_RX_P: U2.27 (L6_UP_RX_P)
ARIES_UP_L6_TX_N: U2.26 (L6_UP_TX_N)
ARIES_UP_L6_TX_P: U2.25 (L6_UP_TX_P)
ARIES_UP_L7_RX_N: U2.32 (L7_UP_RX_N)
ARIES_UP_L7_RX_P: U2.31 (L7_UP_RX_P)
ARIES_UP_L7_TX_N: U2.30 (L7_UP_TX_N)
ARIES_UP_L7_TX_P: U2.29 (L7_UP_TX_P)
BMC_UART_RXD: U4.33 (UART_RXD)
BMC_UART_TXD: U4.32 (UART_TXD)
BUCK_EN: U6.3 (EN)
BUCK_FB: R1.2, R2.1, U6.5 (VSENSE)
BUCK_PGOOD: U6.9 (PGOOD)
ETH_JETSON0_RX_N: J1.30 (MGBE0_RX_N), U1.4 (SDS0_RX_N)
ETH_JETSON0_RX_P: J1.29 (MGBE0_RX_P), U1.3 (SDS0_RX_P)
ETH_JETSON0_TX_N: J1.28 (MGBE0_TX_N), U1.2 (SDS0_TX_N)
ETH_JETSON0_TX_P: J1.27 (MGBE0_TX_P), U1.1 (SDS0_TX_P)
ETH_JETSON1_RX_N: J2.30 (MGBE0_RX_N), U1.8 (SDS1_RX_N)
ETH_JETSON1_RX_P: J2.29 (MGBE0_RX_P), U1.7 (SDS1_RX_P)
ETH_JETSON1_TX_N: J2.28 (MGBE0_TX_N), U1.6 (SDS1_TX_N)
ETH_JETSON1_TX_P: J2.27 (MGBE0_TX_P), U1.5 (SDS1_TX_P)
ETH_JETSON2_RX_N: J3.30 (MGBE0_RX_N), U1.12 (SDS2_RX_N)
ETH_JETSON2_RX_P: J3.29 (MGBE0_RX_P), U1.11 (SDS2_RX_P)
ETH_JETSON2_TX_N: J3.28 (MGBE0_TX_N), U1.10 (SDS2_TX_N)
ETH_JETSON2_TX_P: J3.27 (MGBE0_TX_P), U1.9 (SDS2_TX_P)
ETH_JETSON3_RX_N: J4.30 (MGBE0_RX_N), U1.16 (SDS3_RX_N)
ETH_JETSON3_RX_P: J4.29 (MGBE0_RX_P), U1.15 (SDS3_RX_P)
ETH_JETSON3_TX_N: J4.28 (MGBE0_TX_N), U1.14 (SDS3_TX_N)
ETH_JETSON3_TX_P: J4.27 (MGBE0_TX_P), U1.13 (SDS3_TX_P)
ETH_JETSON4_RX_N: J5.30 (MGBE0_RX_N), U1.20 (SDS4_RX_N)
ETH_JETSON4_RX_P: J5.29 (MGBE0_RX_P), U1.19 (SDS4_RX_P)
ETH_JETSON4_TX_N: J5.28 (MGBE0_TX_N), U1.18 (SDS4_TX_N)
ETH_JETSON4_TX_P: J5.27 (MGBE0_TX_P), U1.17 (SDS4_TX_P)
ETH_JETSON5_RX_N: J6.30 (MGBE0_RX_N), U1.24 (SDS5_RX_N)
ETH_JETSON5_RX_P: J6.29 (MGBE0_RX_P), U1.23 (SDS5_RX_P)
ETH_JETSON5_TX_N: J6.28 (MGBE0_TX_N), U1.22 (SDS5_TX_N)
ETH_JETSON5_TX_P: J6.27 (MGBE0_TX_P), U1.21 (SDS5_TX_P)
ETH_JETSON6_RX_N: J7.30 (MGBE0_RX_N), U1.28 (SDS6_RX_N)
ETH_JETSON6_RX_P: J7.29 (MGBE0_RX_P), U1.27 (SDS6_RX_P)
ETH_JETSON6_TX_N: J7.28 (MGBE0_TX_N), U1.26 (SDS6_TX_N)
ETH_JETSON6_TX_P: J7.27 (MGBE0_TX_P), U1.25 (SDS6_TX_P)
ETH_JETSON7_RX_N: J8.30 (MGBE0_RX_N), U1.32 (SDS7_RX_N)
ETH_JETSON7_RX_P: J8.29 (MGBE0_RX_P), U1.31 (SDS7_RX_P)
ETH_JETSON7_TX_N: J8.28 (MGBE0_TX_N), U1.30 (SDS7_TX_N)
ETH_JETSON7_TX_P: J8.27 (MGBE0_TX_P), U1.29 (SDS7_TX_P)
ETH_JETSON8_RX_N: J9.30 (MGBE0_RX_N), U1.36 (SDS8_RX_N)
ETH_JETSON8_RX_P: J9.29 (MGBE0_RX_P), U1.35 (SDS8_RX_P)
ETH_JETSON8_TX_N: J9.28 (MGBE0_TX_N), U1.34 (SDS8_TX_N)
ETH_JETSON8_TX_P: J9.27 (MGBE0_TX_P), U1.33 (SDS8_TX_P)
ETH_JETSON9_RX_N: J10.30 (MGBE0_RX_N), U1.40 (SDS9_RX_N)
ETH_JETSON9_RX_P: J10.29 (MGBE0_RX_P), U1.39 (SDS9_RX_P)
ETH_JETSON9_TX_N: J10.28 (MGBE0_TX_N), U1.38 (SDS9_TX_N)
ETH_JETSON9_TX_P: J10.27 (MGBE0_TX_P), U1.37 (SDS9_TX_P)
ETH_RYZEN0_L0_RX_N: J11.44 (ETH_RX0_N), U1.44 (SDS10_RX_N)
ETH_RYZEN0_L0_RX_P: J11.43 (ETH_RX0_P), U1.43 (SDS10_RX_P)
ETH_RYZEN0_L0_TX_N: J11.42 (ETH_TX0_N), U1.42 (SDS10_TX_N)
ETH_RYZEN0_L0_TX_P: J11.41 (ETH_TX0_P), U1.41 (SDS10_TX_P)
ETH_RYZEN0_L1_RX_N: J11.48 (ETH_RX1_N), U1.84 (SDS20_RX_N)
ETH_RYZEN0_L1_RX_P: J11.47 (ETH_RX1_P), U1.83 (SDS20_RX_P)
ETH_RYZEN0_L1_TX_N: J11.46 (ETH_TX1_N), U1.82 (SDS20_TX_N)
ETH_RYZEN0_L1_TX_P: J11.45 (ETH_TX1_P), U1.81 (SDS20_TX_P)
ETH_RYZEN0_L2_RX_N: J11.52 (ETH_RX2_N)
ETH_RYZEN0_L2_RX_P: J11.51 (ETH_RX2_P)
ETH_RYZEN0_L2_TX_N: J11.50 (ETH_TX2_N)
ETH_RYZEN0_L2_TX_P: J11.49 (ETH_TX2_P)
ETH_RYZEN0_L3_RX_N: J11.56 (ETH_RX3_N)
ETH_RYZEN0_L3_RX_P: J11.55 (ETH_RX3_P)
ETH_RYZEN0_L3_TX_N: J11.54 (ETH_TX3_N)
ETH_RYZEN0_L3_TX_P: J11.53 (ETH_TX3_P)
ETH_RYZEN1_L0_RX_N: J12.44 (ETH_RX0_N), U1.48 (SDS11_RX_N)
ETH_RYZEN1_L0_RX_P: J12.43 (ETH_RX0_P), U1.47 (SDS11_RX_P)
ETH_RYZEN1_L0_TX_N: J12.42 (ETH_TX0_N), U1.46 (SDS11_TX_N)
ETH_RYZEN1_L0_TX_P: J12.41 (ETH_TX0_P), U1.45 (SDS11_TX_P)
ETH_RYZEN1_L1_RX_N: J12.48 (ETH_RX1_N), U1.88 (SDS21_RX_N)
ETH_RYZEN1_L1_RX_P: J12.47 (ETH_RX1_P), U1.87 (SDS21_RX_P)
ETH_RYZEN1_L1_TX_N: J12.46 (ETH_TX1_N), U1.86 (SDS21_TX_N)
ETH_RYZEN1_L1_TX_P: J12.45 (ETH_TX1_P), U1.85 (SDS21_TX_P)
ETH_RYZEN1_L2_RX_N: J12.52 (ETH_RX2_N)
ETH_RYZEN1_L2_RX_P: J12.51 (ETH_RX2_P)
ETH_RYZEN1_L2_TX_N: J12.50 (ETH_TX2_N)
ETH_RYZEN1_L2_TX_P: J12.49 (ETH_TX2_P)
ETH_RYZEN1_L3_RX_N: J12.56 (ETH_RX3_N)
ETH_RYZEN1_L3_RX_P: J12.55 (ETH_RX3_P)
ETH_RYZEN1_L3_TX_N: J12.54 (ETH_TX3_N)
ETH_RYZEN1_L3_TX_P: J12.53 (ETH_TX3_P)
ETH_RYZEN2_L0_RX_N: J13.44 (ETH_RX0_N), U1.52 (SDS12_RX_N)
ETH_RYZEN2_L0_RX_P: J13.43 (ETH_RX0_P), U1.51 (SDS12_RX_P)
ETH_RYZEN2_L0_TX_N: J13.42 (ETH_TX0_N), U1.50 (SDS12_TX_N)
ETH_RYZEN2_L0_TX_P: J13.41 (ETH_TX0_P), U1.49 (SDS12_TX_P)
ETH_RYZEN2_L1_RX_N: J13.48 (ETH_RX1_N), U1.92 (SDS22_RX_N)
ETH_RYZEN2_L1_RX_P: J13.47 (ETH_RX1_P), U1.91 (SDS22_RX_P)
ETH_RYZEN2_L1_TX_N: J13.46 (ETH_TX1_N), U1.90 (SDS22_TX_N)
ETH_RYZEN2_L1_TX_P: J13.45 (ETH_TX1_P), U1.89 (SDS22_TX_P)
ETH_RYZEN2_L2_RX_N: J13.52 (ETH_RX2_N)
ETH_RYZEN2_L2_RX_P: J13.51 (ETH_RX2_P)
ETH_RYZEN2_L2_TX_N: J13.50 (ETH_TX2_N)
ETH_RYZEN2_L2_TX_P: J13.49 (ETH_TX2_P)
ETH_RYZEN2_L3_RX_N: J13.56 (ETH_RX3_N)
ETH_RYZEN2_L3_RX_P: J13.55 (ETH_RX3_P)
ETH_RYZEN2_L3_TX_N: J13.54 (ETH_TX3_N)
ETH_RYZEN2_L3_TX_P: J13.53 (ETH_TX3_P)
ETH_RYZEN3_L0_RX_N: J14.44 (ETH_RX0_N), U1.56 (SDS13_RX_N)
ETH_RYZEN3_L0_RX_P: J14.43 (ETH_RX0_P), U1.55 (SDS13_RX_P)
ETH_RYZEN3_L0_TX_N: J14.42 (ETH_TX0_N), U1.54 (SDS13_TX_N)
ETH_RYZEN3_L0_TX_P: J14.41 (ETH_TX0_P), U1.53 (SDS13_TX_P)
ETH_RYZEN3_L1_RX_N: J14.48 (ETH_RX1_N), U1.96 (SDS23_RX_N)
ETH_RYZEN3_L1_RX_P: J14.47 (ETH_RX1_P), U1.95 (SDS23_RX_P)
ETH_RYZEN3_L1_TX_N: J14.46 (ETH_TX1_N), U1.94 (SDS23_TX_N)
ETH_RYZEN3_L1_TX_P: J14.45 (ETH_TX1_P), U1.93 (SDS23_TX_P)
ETH_RYZEN3_L2_RX_N: J14.52 (ETH_RX2_N)
ETH_RYZEN3_L2_RX_P: J14.51 (ETH_RX2_P)
ETH_RYZEN3_L2_TX_N: J14.50 (ETH_TX2_N)
ETH_RYZEN3_L2_TX_P: J14.49 (ETH_TX2_P)
ETH_RYZEN3_L3_RX_N: J14.56 (ETH_RX3_N)
ETH_RYZEN3_L3_RX_P: J14.55 (ETH_RX3_P)
ETH_RYZEN3_L3_TX_N: J14.54 (ETH_TX3_N)
ETH_RYZEN3_L3_TX_P: J14.53 (ETH_TX3_P)
ETH_RYZEN4_L0_RX_N: J15.44 (ETH_RX0_N), U1.60 (SDS14_RX_N)
ETH_RYZEN4_L0_RX_P: J15.43 (ETH_RX0_P), U1.59 (SDS14_RX_P)
ETH_RYZEN4_L0_TX_N: J15.42 (ETH_TX0_N), U1.58 (SDS14_TX_N)
ETH_RYZEN4_L0_TX_P: J15.41 (ETH_TX0_P), U1.57 (SDS14_TX_P)
ETH_RYZEN4_L1_RX_N: J15.48 (ETH_RX1_N), U1.100 (SDS24_RX_N)
ETH_RYZEN4_L1_RX_P: J15.47 (ETH_RX1_P), U1.99 (SDS24_RX_P)
ETH_RYZEN4_L1_TX_N: J15.46 (ETH_TX1_N), U1.98 (SDS24_TX_N)
ETH_RYZEN4_L1_TX_P: J15.45 (ETH_TX1_P), U1.97 (SDS24_TX_P)
ETH_RYZEN4_L2_RX_N: J15.52 (ETH_RX2_N)
ETH_RYZEN4_L2_RX_P: J15.51 (ETH_RX2_P)
ETH_RYZEN4_L2_TX_N: J15.50 (ETH_TX2_N)
ETH_RYZEN4_L2_TX_P: J15.49 (ETH_TX2_P)
ETH_RYZEN4_L3_RX_N: J15.56 (ETH_RX3_N)
ETH_RYZEN4_L3_RX_P: J15.55 (ETH_RX3_P)
ETH_RYZEN4_L3_TX_N: J15.54 (ETH_TX3_N)
ETH_RYZEN4_L3_TX_P: J15.53 (ETH_TX3_P)
ETH_RYZEN5_L0_RX_N: J16.44 (ETH_RX0_N), U1.64 (SDS15_RX_N)
ETH_RYZEN5_L0_RX_P: J16.43 (ETH_RX0_P), U1.63 (SDS15_RX_P)
ETH_RYZEN5_L0_TX_N: J16.42 (ETH_TX0_N), U1.62 (SDS15_TX_N)
ETH_RYZEN5_L0_TX_P: J16.41 (ETH_TX0_P), U1.61 (SDS15_TX_P)
ETH_RYZEN5_L1_RX_N: J16.48 (ETH_RX1_N), U1.104 (SDS25_RX_N)
ETH_RYZEN5_L1_RX_P: J16.47 (ETH_RX1_P), U1.103 (SDS25_RX_P)
ETH_RYZEN5_L1_TX_N: J16.46 (ETH_TX1_N), U1.102 (SDS25_TX_N)
ETH_RYZEN5_L1_TX_P: J16.45 (ETH_TX1_P), U1.101 (SDS25_TX_P)
ETH_RYZEN5_L2_RX_N: J16.52 (ETH_RX2_N)
ETH_RYZEN5_L2_RX_P: J16.51 (ETH_RX2_P)
ETH_RYZEN5_L2_TX_N: J16.50 (ETH_TX2_N)
ETH_RYZEN5_L2_TX_P: J16.49 (ETH_TX2_P)
ETH_RYZEN5_L3_RX_N: J16.56 (ETH_RX3_N)
ETH_RYZEN5_L3_RX_P: J16.55 (ETH_RX3_P)
ETH_RYZEN5_L3_TX_N: J16.54 (ETH_TX3_N)
ETH_RYZEN5_L3_TX_P: J16.53 (ETH_TX3_P)
ETH_RYZEN6_L0_RX_N: J17.44 (ETH_RX0_N), U1.68 (SDS16_RX_N)
ETH_RYZEN6_L0_RX_P: J17.43 (ETH_RX0_P), U1.67 (SDS16_RX_P)
ETH_RYZEN6_L0_TX_N: J17.42 (ETH_TX0_N), U1.66 (SDS16_TX_N)
ETH_RYZEN6_L0_TX_P: J17.41 (ETH_TX0_P), U1.65 (SDS16_TX_P)
ETH_RYZEN6_L1_RX_N: J17.48 (ETH_RX1_N), U1.108 (SDS26_RX_N)
ETH_RYZEN6_L1_RX_P: J17.47 (ETH_RX1_P), U1.107 (SDS26_RX_P)
ETH_RYZEN6_L1_TX_N: J17.46 (ETH_TX1_N), U1.106 (SDS26_TX_N)
ETH_RYZEN6_L1_TX_P: J17.45 (ETH_TX1_P), U1.105 (SDS26_TX_P)
ETH_RYZEN6_L2_RX_N: J17.52 (ETH_RX2_N)
ETH_RYZEN6_L2_RX_P: J17.51 (ETH_RX2_P)
ETH_RYZEN6_L2_TX_N: J17.50 (ETH_TX2_N)
ETH_RYZEN6_L2_TX_P: J17.49 (ETH_TX2_P)
ETH_RYZEN6_L3_RX_N: J17.56 (ETH_RX3_N)
ETH_RYZEN6_L3_RX_P: J17.55 (ETH_RX3_P)
ETH_RYZEN6_L3_TX_N: J17.54 (ETH_TX3_N)
ETH_RYZEN6_L3_TX_P: J17.53 (ETH_TX3_P)
ETH_RYZEN7_L0_RX_N: J18.44 (ETH_RX0_N), U1.72 (SDS17_RX_N)
ETH_RYZEN7_L0_RX_P: J18.43 (ETH_RX0_P), U1.71 (SDS17_RX_P)
ETH_RYZEN7_L0_TX_N: J18.42 (ETH_TX0_N), U1.70 (SDS17_TX_N)
ETH_RYZEN7_L0_TX_P: J18.41 (ETH_TX0_P), U1.69 (SDS17_TX_P)
ETH_RYZEN7_L1_RX_N: J18.48 (ETH_RX1_N), U1.112 (SDS27_RX_N)
ETH_RYZEN7_L1_RX_P: J18.47 (ETH_RX1_P), U1.111 (SDS27_RX_P)
ETH_RYZEN7_L1_TX_N: J18.46 (ETH_TX1_N), U1.110 (SDS27_TX_N)
ETH_RYZEN7_L1_TX_P: J18.45 (ETH_TX1_P), U1.109 (SDS27_TX_P)
ETH_RYZEN7_L2_RX_N: J18.52 (ETH_RX2_N)
ETH_RYZEN7_L2_RX_P: J18.51 (ETH_RX2_P)
ETH_RYZEN7_L2_TX_N: J18.50 (ETH_TX2_N)
ETH_RYZEN7_L2_TX_P: J18.49 (ETH_TX2_P)
ETH_RYZEN7_L3_RX_N: J18.56 (ETH_RX3_N)
ETH_RYZEN7_L3_RX_P: J18.55 (ETH_RX3_P)
ETH_RYZEN7_L3_TX_N: J18.54 (ETH_TX3_N)
ETH_RYZEN7_L3_TX_P: J18.53 (ETH_TX3_P)
ETH_RYZEN8_L0_RX_N: J19.44 (ETH_RX0_N), U1.76 (SDS18_RX_N)
ETH_RYZEN8_L0_RX_P: J19.43 (ETH_RX0_P), U1.75 (SDS18_RX_P)
ETH_RYZEN8_L0_TX_N: J19.42 (ETH_TX0_N), U1.74 (SDS18_TX_N)
ETH_RYZEN8_L0_TX_P: J19.41 (ETH_TX0_P), U1.73 (SDS18_TX_P)
ETH_RYZEN8_L1_RX_N: J19.48 (ETH_RX1_N), U1.116 (SDS28_RX_N)
ETH_RYZEN8_L1_RX_P: J19.47 (ETH_RX1_P), U1.115 (SDS28_RX_P)
ETH_RYZEN8_L1_TX_N: J19.46 (ETH_TX1_N), U1.114 (SDS28_TX_N)
ETH_RYZEN8_L1_TX_P: J19.45 (ETH_TX1_P), U1.113 (SDS28_TX_P)
ETH_RYZEN8_L2_RX_N: J19.52 (ETH_RX2_N)
ETH_RYZEN8_L2_RX_P: J19.51 (ETH_RX2_P)
ETH_RYZEN8_L2_TX_N: J19.50 (ETH_TX2_N)
ETH_RYZEN8_L2_TX_P: J19.49 (ETH_TX2_P)
ETH_RYZEN8_L3_RX_N: J19.56 (ETH_RX3_N)
ETH_RYZEN8_L3_RX_P: J19.55 (ETH_RX3_P)
ETH_RYZEN8_L3_TX_N: J19.54 (ETH_TX3_N)
ETH_RYZEN8_L3_TX_P: J19.53 (ETH_TX3_P)
ETH_RYZEN9_L0_RX_N: J20.44 (ETH_RX0_N), U1.80 (SDS19_RX_N)
ETH_RYZEN9_L0_RX_P: J20.43 (ETH_RX0_P), U1.79 (SDS19_RX_P)
ETH_RYZEN9_L0_TX_N: J20.42 (ETH_TX0_N), U1.78 (SDS19_TX_N)
ETH_RYZEN9_L0_TX_P: J20.41 (ETH_TX0_P), U1.77 (SDS19_TX_P)
ETH_RYZEN9_L1_RX_N: J20.48 (ETH_RX1_N), U1.120 (SDS29_RX_N)
ETH_RYZEN9_L1_RX_P: J20.47 (ETH_RX1_P), U1.119 (SDS29_RX_P)
ETH_RYZEN9_L1_TX_N: J20.46 (ETH_TX1_N), U1.118 (SDS29_TX_N)
ETH_RYZEN9_L1_TX_P: J20.45 (ETH_TX1_P), U1.117 (SDS29_TX_P)
ETH_RYZEN9_L2_RX_N: J20.52 (ETH_RX2_N)
ETH_RYZEN9_L2_RX_P: J20.51 (ETH_RX2_P)
ETH_RYZEN9_L2_TX_N: J20.50 (ETH_TX2_N)
ETH_RYZEN9_L2_TX_P: J20.49 (ETH_TX2_P)
ETH_RYZEN9_L3_RX_N: J20.56 (ETH_RX3_N)
ETH_RYZEN9_L3_RX_P: J20.55 (ETH_RX3_P)
ETH_RYZEN9_L3_TX_N: J20.54 (ETH_TX3_N)
ETH_RYZEN9_L3_TX_P: J20.53 (ETH_TX3_P)
FAN0_PWM: U4.16 (FAN0_PWM)
FAN0_TACH: U4.1 (FAN0_TACH)
FAN1_PWM: U4.17 (FAN1_PWM)
FAN1_TACH: U4.2 (FAN1_TACH)
FAN2_PWM: U4.18 (FAN2_PWM)
FAN2_TACH: U4.3 (FAN2_TACH)
FAN3_PWM: U4.19 (FAN3_PWM)
FAN3_TACH: U4.4 (FAN3_TACH)
FAN4_PWM: U4.20 (FAN4_PWM)
FAN4_TACH: U4.5 (FAN4_TACH)
FAN5_PWM: U4.21 (FAN5_PWM)
FAN5_TACH: U4.6 (FAN5_TACH)
GND: C1.2, C2.2, C3.2, C4.2, J1.1 (GND), J1.2 (GND), J1.129 (GND), J1.130 (GND), J1.135 (GND), J1.136 (GND), J1.259 (GND), J1.260 (GND), J2.1 (GND), J2.2 (GND), J2.129 (GND), J2.130 (GND), J2.135 (GND), J2.136 (GND), J2.259 (GND), J2.260 (GND), J3.1 (GND), J3.2 (GND), J3.129 (GND), J3.130 (GND), J3.135 (GND), J3.136 (GND), J3.259 (GND), J3.260 (GND), J4.1 (GND), J4.2 (GND), J4.129 (GND), J4.130 (GND), J4.135 (GND), J4.136 (GND), J4.259 (GND), J4.260 (GND), J5.1 (GND), J5.2 (GND), J5.129 (GND), J5.130 (GND), J5.135 (GND), J5.136 (GND), J5.259 (GND), J5.260 (GND), J6.1 (GND), J6.2 (GND), J6.129 (GND), J6.130 (GND), J6.135 (GND), J6.136 (GND), J6.259 (GND), J6.260 (GND), J7.1 (GND), J7.2 (GND), J7.129 (GND), J7.130 (GND), J7.135 (GND), J7.136 (GND), J7.259 (GND), J7.260 (GND), J8.1 (GND), J8.2 (GND), J8.129 (GND), J8.130 (GND), J8.135 (GND), J8.136 (GND), J8.259 (GND), J8.260 (GND), J9.1 (GND), J9.2 (GND), J9.129 (GND), J9.130 (GND), J9.135 (GND), J9.136 (GND), J9.259 (GND), J9.260 (GND), J10.1 (GND), J10.2 (GND), J10.129 (GND), J10.130 (GND)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
I2C_SCL: U1.146 (I2C_MGMT_SCL), U2.71 (SMB_CLK), U2.73 (I2C_MGMT_SCL)
I2C_SDA: U1.147 (I2C_MGMT_SDA), U2.72 (SMB_DAT), U2.74 (I2C_MGMT_SDA)
JETSON0_CSI0_CLK_N: J1.158 (CSI0_CLK_N)
JETSON0_CSI0_CLK_P: J1.157 (CSI0_CLK_P)
JETSON0_CSI0_D0_N: J1.154 (CSI0_D0_N)
JETSON0_CSI0_D0_P: J1.153 (CSI0_D0_P)
JETSON0_CSI0_D1_N: J1.156 (CSI0_D1_N)
JETSON0_CSI0_D1_P: J1.155 (CSI0_D1_P)
JETSON0_DP0_TX0_N: J1.146 (DP0_TX0_N)
JETSON0_DP0_TX0_P: J1.145 (DP0_TX0_P)
JETSON0_DP0_TX1_N: J1.148 (DP0_TX1_N)
JETSON0_DP0_TX1_P: J1.147 (DP0_TX1_P)
JETSON0_DP0_TX2_N: J1.150 (DP0_TX2_N)
JETSON0_DP0_TX2_P: J1.149 (DP0_TX2_P)
JETSON0_DP0_TX3_N: J1.152 (DP0_TX3_N)
JETSON0_DP0_TX3_P: J1.151 (DP0_TX3_P)
JETSON0_EN: J1.160 (POWER_EN), U3.1 (EN0)
JETSON0_HDMI_TX0_N: J1.138 (HDMI_TX0_N)
JETSON0_HDMI_TX0_P: J1.137 (HDMI_TX0_P)
JETSON0_HDMI_TX1_N: J1.140 (HDMI_TX1_N)
JETSON0_HDMI_TX1_P: J1.139 (HDMI_TX1_P)
JETSON0_HDMI_TX2_N: J1.142 (HDMI_TX2_N)
JETSON0_HDMI_TX2_P: J1.141 (HDMI_TX2_P)
JETSON0_HDMI_TXC_N: J1.144 (HDMI_TXC_N)
JETSON0_HDMI_TXC_P: J1.143 (HDMI_TXC_P)
JETSON0_I2C_SCL: J1.19 (I2C_GP0_SCL)
JETSON0_I2C_SDA: J1.20 (I2C_GP0_SDA)
JETSON0_MOD_ALIVE: J1.32 (MOD_ALIVE)
JETSON0_MOD_SLEEP_L: J1.31 (MOD_SLEEP_L)
JETSON0_PEX0_CLK_N: J1.16 (PEX0_CLK_N)
JETSON0_PEX0_CLK_P: J1.15 (PEX0_CLK_P)
JETSON0_PEX0_RST_L: J1.17 (PEX0_RST_L)
JETSON0_PEX0_RX0_N: J1.10 (PEX0_RX0_N)
JETSON0_PEX0_RX0_P: J1.9 (PEX0_RX0_P)
JETSON0_PEX0_RX1_N: J1.14 (PEX0_RX1_N)
JETSON0_PEX0_RX1_P: J1.13 (PEX0_RX1_P)
JETSON0_PEX0_TX0_N: J1.8 (PEX0_TX0_N)
JETSON0_PEX0_TX0_P: J1.7 (PEX0_TX0_P)
JETSON0_PEX0_TX1_N: J1.12 (PEX0_TX1_N)
JETSON0_PEX0_TX1_P: J1.11 (PEX0_TX1_P)
JETSON0_PEX0_WAKE_L: J1.18 (PEX0_WAKE_L)
JETSON0_PGOOD: U3.33 (PGOOD0)
JETSON0_RST_L: J1.159 (SYS_RESET_L)
JETSON0_SPI_CS_L: J1.26 (SPI0_CS0_L)
JETSON0_SPI_MISO: J1.24 (SPI0_MISO)
JETSON0_SPI_MOSI: J1.23 (SPI0_MOSI)
JETSON0_SPI_SCK: J1.25 (SPI0_SCK)
JETSON0_UART_RXD: J1.22 (UART0_RXD)
JETSON0_UART_TXD: J1.21 (UART0_TXD)
JETSON0_USB0_DN: J1.4 (USB0_DN)
JETSON0_USB0_DP: J1.3 (USB0_DP)
JETSON0_USB1_DN: J1.6 (USB1_DN)
JETSON0_USB1_DP: J1.5 (USB1_DP)
JETSON1_CSI0_CLK_N: J2.158 (CSI0_CLK_N)
JETSON1_CSI0_CLK_P: J2.157 (CSI0_CLK_P)
JETSON1_CSI0_D0_N: J2.154 (CSI0_D0_N)
JETSON1_CSI0_D0_P: J2.153 (CSI0_D0_P)
JETSON1_CSI0_D1_N: J2.156 (CSI0_D1_N)
JETSON1_CSI0_D1_P: J2.155 (CSI0_D1_P)
JETSON1_DP0_TX0_N: J2.146 (DP0_TX0_N)
JETSON1_DP0_TX0_P: J2.145 (DP0_TX0_P)
JETSON1_DP0_TX1_N: J2.148 (DP0_TX1_N)
JETSON1_DP0_TX1_P: J2.147 (DP0_TX1_P)
JETSON1_DP0_TX2_N: J2.150 (DP0_TX2_N)
JETSON1_DP0_TX2_P: J2.149 (DP0_TX2_P)
JETSON1_DP0_TX3_N: J2.152 (DP0_TX3_N)
JETSON1_DP0_TX3_P: J2.151 (DP0_TX3_P)
JETSON1_EN: J2.160 (POWER_EN), U3.2 (EN1)
JETSON1_HDMI_TX0_N: J2.138 (HDMI_TX0_N)
JETSON1_HDMI_TX0_P: J2.137 (HDMI_TX0_P)
JETSON1_HDMI_TX1_N: J2.140 (HDMI_TX1_N)
JETSON1_HDMI_TX1_P: J2.139 (HDMI_TX1_P)
JETSON1_HDMI_TX2_N: J2.142 (HDMI_TX2_N)
JETSON1_HDMI_TX2_P: J2.141 (HDMI_TX2_P)
JETSON1_HDMI_TXC_N: J2.144 (HDMI_TXC_N)
JETSON1_HDMI_TXC_P: J2.143 (HDMI_TXC_P)
JETSON1_I2C_SCL: J2.19 (I2C_GP0_SCL)
JETSON1_I2C_SDA: J2.20 (I2C_GP0_SDA)
JETSON1_MOD_ALIVE: J2.32 (MOD_ALIVE)
JETSON1_MOD_SLEEP_L: J2.31 (MOD_SLEEP_L)
JETSON1_PEX0_CLK_N: J2.16 (PEX0_CLK_N)
JETSON1_PEX0_CLK_P: J2.15 (PEX0_CLK_P)
JETSON1_PEX0_RST_L: J2.17 (PEX0_RST_L)
JETSON1_PEX0_RX0_N: J2.10 (PEX0_RX0_N)
JETSON1_PEX0_RX0_P: J2.9 (PEX0_RX0_P)
JETSON1_PEX0_RX1_N: J2.14 (PEX0_RX1_N)
JETSON1_PEX0_RX1_P: J2.13 (PEX0_RX1_P)
JETSON1_PEX0_TX0_N: J2.8 (PEX0_TX0_N)
JETSON1_PEX0_TX0_P: J2.7 (PEX0_TX0_P)
JETSON1_PEX0_TX1_N: J2.12 (PEX0_TX1_N)
JETSON1_PEX0_TX1_P: J2.11 (PEX0_TX1_P)
JETSON1_PEX0_WAKE_L: J2.18 (PEX0_WAKE_L)
JETSON1_PGOOD: U3.34 (PGOOD1)
JETSON1_RST_L: J2.159 (SYS_RESET_L)
JETSON1_SPI_CS_L: J2.26 (SPI0_CS0_L)
JETSON1_SPI_MISO: J2.24 (SPI0_MISO)
JETSON1_SPI_MOSI: J2.23 (SPI0_MOSI)
JETSON1_SPI_SCK: J2.25 (SPI0_SCK)
JETSON1_UART_RXD: J2.22 (UART0_RXD)
JETSON1_UART_TXD: J2.21 (UART0_TXD)
JETSON1_USB0_DN: J2.4 (USB0_DN)
JETSON1_USB0_DP: J2.3 (USB0_DP)
JETSON1_USB1_DN: J2.6 (USB1_DN)
JETSON1_USB1_DP: J2.5 (USB1_DP)
JETSON2_CSI0_CLK_N: J3.158 (CSI0_CLK_N)
JETSON2_CSI0_CLK_P: J3.157 (CSI0_CLK_P)
JETSON2_CSI0_D0_N: J3.154 (CSI0_D0_N)
JETSON2_CSI0_D0_P: J3.153 (CSI0_D0_P)
JETSON2_CSI0_D1_N: J3.156 (CSI0_D1_N)
JETSON2_CSI0_D1_P: J3.155 (CSI0_D1_P)
JETSON2_DP0_TX0_N: J3.146 (DP0_TX0_N)
JETSON2_DP0_TX0_P: J3.145 (DP0_TX0_P)
JETSON2_DP0_TX1_N: J3.148 (DP0_TX1_N)
JETSON2_DP0_TX1_P: J3.147 (DP0_TX1_P)
JETSON2_DP0_TX2_N: J3.150 (DP0_TX2_N)
JETSON2_DP0_TX2_P: J3.149 (DP0_TX2_P)
JETSON2_DP0_TX3_N: J3.152 (DP0_TX3_N)
JETSON2_DP0_TX3_P: J3.151 (DP0_TX3_P)
JETSON2_EN: J3.160 (POWER_EN), U3.3 (EN2)
JETSON2_HDMI_TX0_N: J3.138 (HDMI_TX0_N)
JETSON2_HDMI_TX0_P: J3.137 (HDMI_TX0_P)
JETSON2_HDMI_TX1_N: J3.140 (HDMI_TX1_N)
JETSON2_HDMI_TX1_P: J3.139 (HDMI_TX1_P)
JETSON2_HDMI_TX2_N: J3.142 (HDMI_TX2_N)
JETSON2_HDMI_TX2_P: J3.141 (HDMI_TX2_P)
JETSON2_HDMI_TXC_N: J3.144 (HDMI_TXC_N)
JETSON2_HDMI_TXC_P: J3.143 (HDMI_TXC_P)
JETSON2_I2C_SCL: J3.19 (I2C_GP0_SCL)
JETSON2_I2C_SDA: J3.20 (I2C_GP0_SDA)
JETSON2_MOD_ALIVE: J3.32 (MOD_ALIVE)
JETSON2_MOD_SLEEP_L: J3.31 (MOD_SLEEP_L)
JETSON2_PEX0_CLK_N: J3.16 (PEX0_CLK_N)
JETSON2_PEX0_CLK_P: J3.15 (PEX0_CLK_P)
JETSON2_PEX0_RST_L: J3.17 (PEX0_RST_L)
JETSON2_PEX0_RX0_N: J3.10 (PEX0_RX0_N)
JETSON2_PEX0_RX0_P: J3.9 (PEX0_RX0_P)
JETSON2_PEX0_RX1_N: J3.14 (PEX0_RX1_N)
JETSON2_PEX0_RX1_P: J3.13 (PEX0_RX1_P)
JETSON2_PEX0_TX0_N: J3.8 (PEX0_TX0_N)
JETSON2_PEX0_TX0_P: J3.7 (PEX0_TX0_P)
JETSON2_PEX0_TX1_N: J3.12 (PEX0_TX1_N)
JETSON2_PEX0_TX1_P: J3.11 (PEX0_TX1_P)
JETSON2_PEX0_WAKE_L: J3.18 (PEX0_WAKE_L)
JETSON2_PGOOD: U3.35 (PGOOD2)
JETSON2_RST_L: J3.159 (SYS_RESET_L)
JETSON2_SPI_CS_L: J3.26 (SPI0_CS0_L)
JETSON2_SPI_MISO: J3.24 (SPI0_MISO)
JETSON2_SPI_MOSI: J3.23 (SPI0_MOSI)
JETSON2_SPI_SCK: J3.25 (SPI0_SCK)
JETSON2_UART_RXD: J3.22 (UART0_RXD)
JETSON2_UART_TXD: J3.21 (UART0_TXD)
JETSON2_USB0_DN: J3.4 (USB0_DN)
JETSON2_USB0_DP: J3.3 (USB0_DP)
JETSON2_USB1_DN: J3.6 (USB1_DN)
JETSON2_USB1_DP: J3.5 (USB1_DP)
JETSON3_CSI0_CLK_N: J4.158 (CSI0_CLK_N)
JETSON3_CSI0_CLK_P: J4.157 (CSI0_CLK_P)
JETSON3_CSI0_D0_N: J4.154 (CSI0_D0_N)
JETSON3_CSI0_D0_P: J4.153 (CSI0_D0_P)
JETSON3_CSI0_D1_N: J4.156 (CSI0_D1_N)
JETSON3_CSI0_D1_P: J4.155 (CSI0_D1_P)
JETSON3_DP0_TX0_N: J4.146 (DP0_TX0_N)
JETSON3_DP0_TX0_P: J4.145 (DP0_TX0_P)
JETSON3_DP0_TX1_N: J4.148 (DP0_TX1_N)
JETSON3_DP0_TX1_P: J4.147 (DP0_TX1_P)
JETSON3_DP0_TX2_N: J4.150 (DP0_TX2_N)
JETSON3_DP0_TX2_P: J4.149 (DP0_TX2_P)
JETSON3_DP0_TX3_N: J4.152 (DP0_TX3_N)
JETSON3_DP0_TX3_P: J4.151 (DP0_TX3_P)
JETSON3_EN: J4.160 (POWER_EN), U3.4 (EN3)
JETSON3_HDMI_TX0_N: J4.138 (HDMI_TX0_N)
JETSON3_HDMI_TX0_P: J4.137 (HDMI_TX0_P)
JETSON3_HDMI_TX1_N: J4.140 (HDMI_TX1_N)
JETSON3_HDMI_TX1_P: J4.139 (HDMI_TX1_P)
JETSON3_HDMI_TX2_N: J4.142 (HDMI_TX2_N)
JETSON3_HDMI_TX2_P: J4.141 (HDMI_TX2_P)
JETSON3_HDMI_TXC_N: J4.144 (HDMI_TXC_N)
JETSON3_HDMI_TXC_P: J4.143 (HDMI_TXC_P)
JETSON3_I2C_SCL: J4.19 (I2C_GP0_SCL)
JETSON3_I2C_SDA: J4.20 (I2C_GP0_SDA)
JETSON3_MOD_ALIVE: J4.32 (MOD_ALIVE)
JETSON3_MOD_SLEEP_L: J4.31 (MOD_SLEEP_L)
JETSON3_PEX0_CLK_N: J4.16 (PEX0_CLK_N)
JETSON3_PEX0_CLK_P: J4.15 (PEX0_CLK_P)
JETSON3_PEX0_RST_L: J4.17 (PEX0_RST_L)
JETSON3_PEX0_RX0_N: J4.10 (PEX0_RX0_N)
JETSON3_PEX0_RX0_P: J4.9 (PEX0_RX0_P)
JETSON3_PEX0_RX1_N: J4.14 (PEX0_RX1_N)
JETSON3_PEX0_RX1_P: J4.13 (PEX0_RX1_P)
JETSON3_PEX0_TX0_N: J4.8 (PEX0_TX0_N)
JETSON3_PEX0_TX0_P: J4.7 (PEX0_TX0_P)
JETSON3_PEX0_TX1_N: J4.12 (PEX0_TX1_N)
JETSON3_PEX0_TX1_P: J4.11 (PEX0_TX1_P)
JETSON3_PEX0_WAKE_L: J4.18 (PEX0_WAKE_L)
JETSON3_PGOOD: U3.36 (PGOOD3)
JETSON3_RST_L: J4.159 (SYS_RESET_L)
JETSON3_SPI_CS_L: J4.26 (SPI0_CS0_L)
JETSON3_SPI_MISO: J4.24 (SPI0_MISO)
JETSON3_SPI_MOSI: J4.23 (SPI0_MOSI)
JETSON3_SPI_SCK: J4.25 (SPI0_SCK)
JETSON3_UART_RXD: J4.22 (UART0_RXD)
JETSON3_UART_TXD: J4.21 (UART0_TXD)
JETSON3_USB0_DN: J4.4 (USB0_DN)
JETSON3_USB0_DP: J4.3 (USB0_DP)
JETSON3_USB1_DN: J4.6 (USB1_DN)
JETSON3_USB1_DP: J4.5 (USB1_DP)
JETSON4_CSI0_CLK_N: J5.158 (CSI0_CLK_N)
JETSON4_CSI0_CLK_P: J5.157 (CSI0_CLK_P)
JETSON4_CSI0_D0_N: J5.154 (CSI0_D0_N)
JETSON4_CSI0_D0_P: J5.153 (CSI0_D0_P)
JETSON4_CSI0_D1_N: J5.156 (CSI0_D1_N)
JETSON4_CSI0_D1_P: J5.155 (CSI0_D1_P)
JETSON4_DP0_TX0_N: J5.146 (DP0_TX0_N)
JETSON4_DP0_TX0_P: J5.145 (DP0_TX0_P)
JETSON4_DP0_TX1_N: J5.148 (DP0_TX1_N)
JETSON4_DP0_TX1_P: J5.147 (DP0_TX1_P)
JETSON4_DP0_TX2_N: J5.150 (DP0_TX2_N)
JETSON4_DP0_TX2_P: J5.149 (DP0_TX2_P)
JETSON4_DP0_TX3_N: J5.152 (DP0_TX3_N)
JETSON4_DP0_TX3_P: J5.151 (DP0_TX3_P)
JETSON4_EN: J5.160 (POWER_EN), U3.5 (EN4)
JETSON4_HDMI_TX0_N: J5.138 (HDMI_TX0_N)
JETSON4_HDMI_TX0_P: J5.137 (HDMI_TX0_P)
JETSON4_HDMI_TX1_N: J5.140 (HDMI_TX1_N)
JETSON4_HDMI_TX1_P: J5.139 (HDMI_TX1_P)
JETSON4_HDMI_TX2_N: J5.142 (HDMI_TX2_N)
JETSON4_HDMI_TX2_P: J5.141 (HDMI_TX2_P)
JETSON4_HDMI_TXC_N: J5.144 (HDMI_TXC_N)
JETSON4_HDMI_TXC_P: J5.143 (HDMI_TXC_P)
JETSON4_I2C_SCL: J5.19 (I2C_GP0_SCL)
JETSON4_I2C_SDA: J5.20 (I2C_GP0_SDA)
JETSON4_MOD_ALIVE: J5.32 (MOD_ALIVE)
JETSON4_MOD_SLEEP_L: J5.31 (MOD_SLEEP_L)
JETSON4_PEX0_CLK_N: J5.16 (PEX0_CLK_N)
JETSON4_PEX0_CLK_P: J5.15 (PEX0_CLK_P)
JETSON4_PEX0_RST_L: J5.17 (PEX0_RST_L)
JETSON4_PEX0_RX0_N: J5.10 (PEX0_RX0_N)
JETSON4_PEX0_RX0_P: J5.9 (PEX0_RX0_P)
JETSON4_PEX0_RX1_N: J5.14 (PEX0_RX1_N)
JETSON4_PEX0_RX1_P: J5.13 (PEX0_RX1_P)
JETSON4_PEX0_TX0_N: J5.8 (PEX0_TX0_N)
JETSON4_PEX0_TX0_P: J5.7 (PEX0_TX0_P)
JETSON4_PEX0_TX1_N: J5.12 (PEX0_TX1_N)
JETSON4_PEX0_TX1_P: J5.11 (PEX0_TX1_P)
JETSON4_PEX0_WAKE_L: J5.18 (PEX0_WAKE_L)
JETSON4_PGOOD: U3.37 (PGOOD4)
JETSON4_RST_L: J5.159 (SYS_RESET_L)
JETSON4_SPI_CS_L: J5.26 (SPI0_CS0_L)
JETSON4_SPI_MISO: J5.24 (SPI0_MISO)
JETSON4_SPI_MOSI: J5.23 (SPI0_MOSI)
JETSON4_SPI_SCK: J5.25 (SPI0_SCK)
JETSON4_UART_RXD: J5.22 (UART0_RXD)
JETSON4_UART_TXD: J5.21 (UART0_TXD)
JETSON4_USB0_DN: J5.4 (USB0_DN)
JETSON4_USB0_DP: J5.3 (USB0_DP)
JETSON4_USB1_DN: J5.6 (USB1_DN)
JETSON4_USB1_DP: J5.5 (USB1_DP)
JETSON5_CSI0_CLK_N: J6.158 (CSI0_CLK_N)
JETSON5_CSI0_CLK_P: J6.157 (CSI0_CLK_P)
JETSON5_CSI0_D0_N: J6.154 (CSI0_D0_N)
JETSON5_CSI0_D0_P: J6.153 (CSI0_D0_P)
JETSON5_CSI0_D1_N: J6.156 (CSI0_D1_N)
JETSON5_CSI0_D1_P: J6.155 (CSI0_D1_P)
JETSON5_DP0_TX0_N: J6.146 (DP0_TX0_N)
JETSON5_DP0_TX0_P: J6.145 (DP0_TX0_P)
JETSON5_DP0_TX1_N: J6.148 (DP0_TX1_N)
JETSON5_DP0_TX1_P: J6.147 (DP0_TX1_P)
JETSON5_DP0_TX2_N: J6.150 (DP0_TX2_N)
JETSON5_DP0_TX2_P: J6.149 (DP0_TX2_P)
JETSON5_DP0_TX3_N: J6.152 (DP0_TX3_N)
JETSON5_DP0_TX3_P: J6.151 (DP0_TX3_P)
JETSON5_EN: J6.160 (POWER_EN), U3.6 (EN5)
JETSON5_HDMI_TX0_N: J6.138 (HDMI_TX0_N)
JETSON5_HDMI_TX0_P: J6.137 (HDMI_TX0_P)
JETSON5_HDMI_TX1_N: J6.140 (HDMI_TX1_N)
JETSON5_HDMI_TX1_P: J6.139 (HDMI_TX1_P)
JETSON5_HDMI_TX2_N: J6.142 (HDMI_TX2_N)
JETSON5_HDMI_TX2_P: J6.141 (HDMI_TX2_P)
JETSON5_HDMI_TXC_N: J6.144 (HDMI_TXC_N)
JETSON5_HDMI_TXC_P: J6.143 (HDMI_TXC_P)
JETSON5_I2C_SCL: J6.19 (I2C_GP0_SCL)
JETSON5_I2C_SDA: J6.20 (I2C_GP0_SDA)
JETSON5_MOD_ALIVE: J6.32 (MOD_ALIVE)
JETSON5_MOD_SLEEP_L: J6.31 (MOD_SLEEP_L)
JETSON5_PEX0_CLK_N: J6.16 (PEX0_CLK_N)
JETSON5_PEX0_CLK_P: J6.15 (PEX0_CLK_P)
JETSON5_PEX0_RST_L: J6.17 (PEX0_RST_L)
JETSON5_PEX0_RX0_N: J6.10 (PEX0_RX0_N)
JETSON5_PEX0_RX0_P: J6.9 (PEX0_RX0_P)
JETSON5_PEX0_RX1_N: J6.14 (PEX0_RX1_N)
JETSON5_PEX0_RX1_P: J6.13 (PEX0_RX1_P)
JETSON5_PEX0_TX0_N: J6.8 (PEX0_TX0_N)
JETSON5_PEX0_TX0_P: J6.7 (PEX0_TX0_P)
JETSON5_PEX0_TX1_N: J6.12 (PEX0_TX1_N)
JETSON5_PEX0_TX1_P: J6.11 (PEX0_TX1_P)
JETSON5_PEX0_WAKE_L: J6.18 (PEX0_WAKE_L)
JETSON5_PGOOD: U3.38 (PGOOD5)
JETSON5_RST_L: J6.159 (SYS_RESET_L)
JETSON5_SPI_CS_L: J6.26 (SPI0_CS0_L)
JETSON5_SPI_MISO: J6.24 (SPI0_MISO)
JETSON5_SPI_MOSI: J6.23 (SPI0_MOSI)
JETSON5_SPI_SCK: J6.25 (SPI0_SCK)
JETSON5_UART_RXD: J6.22 (UART0_RXD)
JETSON5_UART_TXD: J6.21 (UART0_TXD)
JETSON5_USB0_DN: J6.4 (USB0_DN)
JETSON5_USB0_DP: J6.3 (USB0_DP)
JETSON5_USB1_DN: J6.6 (USB1_DN)
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
Board: 4 copper layers, 40 parts (0 on the bottom side), 170 nets, no tracks yet.

Other parts of the board:
MK1, MK2, MK3, MK4, MK5, MK6: MountingHole_M3
